# Keil uVision project Test8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Test8051 +hex
  c flags: Optimize=9
  c include: .\SIOFS;C:\Keil\C51\ISD51;.\FATFS
  group Source
    ./: STARTUP.A51 compactflash.c delay.c led.c main.c sysctrl.c test.c sio.c ISD51.A51
  group FATFS
    ./FATFS/: diskio.c ff.c ffsystem.c cfdiskio.c dvddiskio.c ffunicode.c ramdiskio.c sddiskio.c
